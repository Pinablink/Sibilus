# IAR project ggiz_sibilus.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: asm.s43
    ../../../LIB_MSP430/: FLASH_CTR.s43
    lib/: FLASH_SIBILUS_CTR.s43 GGIZ_SIBILUS_CIFRA_A.h GGIZ_SIBILUS_CIFRA_B.h GGIZ_SIBILUS_CIFRA_C.h GGIZ_SIBILUS_CIFRA_D.h GGIZ_SIBILUS_CIFRA_E.h GGIZ_SIBILUS_CIFRA_F.h GGIZ_SIBILUS_CIFRA_G.h GGIZ_SIBILUS_HEADER.h LOAD_SIBILUS_CIFRAS.s43
